v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {Access_2T2R.sym} -160 -120 0 0 {name=x1}
C {Access_4T.sym} 200 -120 0 0 {name=x2}
