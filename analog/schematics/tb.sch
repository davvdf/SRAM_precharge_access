v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {Access_2T2R.sym} -190 0 0 0 {name=x1}
C {Access_4T.sym} 170 0 0 0 {name=x2}
C {title.sym} -340 440 0 0 {name=l1 author="David Gao"}
